options:
  parameters:
    generate_options: qt_gui
    id: BPSK_BER_simulation
    output_language: python
  states: {}

blocks:
- name: QPSK_MAP
  id: variable
  parameters:
    value: '[-1-1j, 1-1j, -1+1j, 1+1j]'
  states: {}
- name: SNR
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    start: '-15'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: modulation
  id: variable
  parameters:
    value: digital.constellation_bpsk().base()
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e4
  states: {}
- name: GT_sink
  id: virtual_sink
  parameters:
    stream_id: GT
  states: {}
- name: GT_src
  id: virtual_source
  parameters:
    stream_id: GT
  states: {}
- name: Receiver_snk
  id: virtual_sink
  parameters:
    stream_id: Receiver
  states: {}
- name: Receiver_src
  id: virtual_source
  parameters:
    stream_id: Receiver
  states: {}
- name: Transmitter_Src
  id: virtual_source
  parameters:
    stream_id: Transmitter
  states: {}
- name: Transmitter_snk
  id: virtual_sink
  parameters:
    stream_id: Transmitter
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: math.sqrt(10**(-SNR/10)*2)
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: QPSK_MAP
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(self, window_size=100000):
              gr.sync_block.__init__(
                  self,
                  name='BER for QPSK',
                  in_sig=[np.byte, np.byte],
                  out_sig=[np.float32]
              )

              self.window_size = int(window_size)
              self.window = np.zeros(self.window_size, dtype=np.float32)
              self.win_ptr = 0


          def work(self, input_items, output_items):

              a = input_items[0].astype(np.uint8)
              b = input_items[1].astype(np.uint8)

              # sync_block guarantees same input lengths
              n = len(a)

              # XOR to find bit mismatches
              err = (a ^ b) & 0x03

              # Count bit errors (0,1,2)
              biterrors = ((err & 0x01) + ((err & 0x02) >> 1)).astype(np.float32)

              # Update cyclic window
              for k in range(n):
                  self.window[self.win_ptr] = biterrors[k]
                  self.win_ptr = (self.win_ptr + 1) % self.window_size

              # True BER per bit (2 bits per QPSK symbol)
              BER = np.sum(self.window) / (2*self.window_size)

              # Must output exactly n samples
              output_items[0][:] = BER

              return len(output_items[0])
    comment: Block updated 2/14/2026
    window_size: 1e6
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='QPSK Decoder',
                  in_sig=[np.complex64],
                  out_sig=[np.uint8]
              )

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]

              I = (np.real(x) >= 0).astype(np.uint8)
              Q = (np.imag(x) >= 0).astype(np.uint8)

              # quad code: BL=0, BR=1, TL=2, TR=3
              quad = (Q << 1) | I

              # map quad -> QPSK_MAP index: BL->0, BR->1, TL->2, TR->3
              lut = np.array([0, 1, 2, 3], dtype=np.uint8)
              y[:] = lut[quad]

              return len(output_items[0])
    comment: Block Updated 2/14/26
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
    xmax: '5'
    xmin: '-5'
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '-0.1'
    name: '"Bit Error Rate Lab Result"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '-0.1'
    name: '"Bit Error Rate Gnd Truth"'
    type: float
  states: {}
- name: rpi_iot_BER_bbf_0
  id: rpi_iot_BER_bbf
  parameters:
    bit_per_symbol: '2'
    comment: |-
      Use this ground-truth block to
      check the correctness of your code.
    window_size: '1000000'
  states: {}
- name: rpi_iot_QPSK_Decoder_cb_0
  id: rpi_iot_QPSK_Decoder_cb
  parameters:
    comment: |-
      Use this ground-truth block to
      check the correctness of your code.
  states: {}

connections:
- [GT_src, '0', epy_block_0, '1']
- [GT_src, '0', rpi_iot_BER_bbf_0, '1']
- [Receiver_src, '0', epy_block_0_0, '0']
- [Receiver_src, '0', rpi_iot_QPSK_Decoder_cb_0, '0']
- [Transmitter_Src, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0_0, '0', GT_sink, '0']
- [analog_random_source_x_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_add_xx_0, '0', Receiver_snk, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0_0, '0', Transmitter_snk, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_throttle_0_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0_0, '0', epy_block_0, '0']
- [rpi_iot_BER_bbf_0, '0', qtgui_number_sink_1, '0']
- [rpi_iot_QPSK_Decoder_cb_0, '0', rpi_iot_BER_bbf_0, '0']

metadata:
  file_format: 1
